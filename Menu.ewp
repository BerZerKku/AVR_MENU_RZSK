# IAR project Menu.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.newCCIncludePaths: INC
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm128s.xcl
  XLINK.XExtraOptions: -Ointel-extended,(CODE)=.flash.hex
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
  group (top)
    doc/: readme_RZSK.txt
  group Common sources/inc
    inc/: DataCenter.h DataCenter1.h driverLCD.h Flash.h InterfaceS.h Menu.h MyDef.h StandartProtocol.h StartSetup.h WatchDog.h
  group Common sources/src
    src/: DataCenter.c DataCenter1.c driverLCD.c drvKeyboard.cpp InterfaceS.c StartSetup.c studyATmega162.c WatchDog.c
